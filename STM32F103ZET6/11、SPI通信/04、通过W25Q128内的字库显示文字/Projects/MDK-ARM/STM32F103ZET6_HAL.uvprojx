# Keil uVision project STM32F103ZET6_HAL.uvprojx, settings and files
target STM32_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers;..\..\Drivers\BSP;..\..\Drivers\BSP\inc;..\..\Drivers\Libraries;..\..\Drivers\Libraries\CMSIS\Include;..\..\Drivers\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\Libraries\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Drivers\SYSTEM;..\..\Drivers\SYSTEM\inc;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: stm32f1xx_it.c main.c
    ../../Drivers/Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group System
    ../../Drivers/SYSTEM/src/: sys.c delay.c usart.c
  group STM32F1xx_HAL_Driver
    ../../Drivers/Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c
  group BSP
    ../../Drivers/BSP/src/: fsmc.c lcd.c spi.c w25q128.c show.c
